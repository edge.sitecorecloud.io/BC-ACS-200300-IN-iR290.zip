Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-12-13T11:59:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 13 11:59:09 2021 * Host: MBACIU-RO-LE * Database: C:\Users\Mbaciu\AppData\Local\Temp\{F3A86B13-FA9A-41FB-8C37-72CEF53E0913}\ifc * Database version: 5507 * Database creation date: Mon Dec 13 11:59:08 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Dec 13 11:59:08 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 13 11:59:08 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Design Option: Main Model; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: BC ACS 2001E iR290, HC_Boiler_MEPcontent_BAXI_BC ACS 2001E-3001E iR290_ES-ES:BC ACS 2001E iR290:1303214
In: F00
Type - Material: Color RAL 9016, Color RGB 000-056-130, Color RGB 040-040-040, Color RAL 7004, Color RGB 181-166-066, Color RGB 198-000-000, Color RGB 000-000-255
Type - Dimensions - Central Heating Diameter: 19.05 mm; Condensate Drain Diameter: 29 mm; Depth: 705 mm; Diameter: 666 mm; Domestic Cold Water Diameter: 19.05 mm; Domestic Hot Water Diameter: 19.05 mm; Exhaust Air Diameter: 160 mm; Height: 1528 mm; Hydronic Return Diameter: 19.05 mm; Hydronic Supply Diameter: 19.05 mm; Supply Air Diameter: 160 mm; Use Nominal Diameter: yes
Type - Electrical - Loads - Power: 0 W
Type - Identity Data - Article Description: Water heater with heat pump; Article Type: BC ACS 2001E iR290; Base Family Version: 12.34; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Water heater with heat pump; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.33; Manufacturer: BAXI; Manufacturer Art. No.: 7785394; Manufacturer URL: https://www.baxi.es/; MEPcontent Class: BOILER; Model: BC ACS 2001E iR290; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: BAXI; Revit Version: 2019; Type Name: BC ACS 2001E iR290; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Color: Color RAL 7004; Light Grey: Color RAL 7004; Red: Color RAL 7004; White: Color RAL 9016; Yellow: Color RGB 181-166-066
Type - Mechanical - CW Label: 0; Nominal Power 50-30°C: 0; Nominal Power 80-60°C: 0; Tap Capacity at 60°C: 0; Volume: 0 m3
Type - Other - Category: Mechanical Equipment; Boiler Height: 1504 mm; Connector Angle: 70.43 deg; Connector Height 1: 615 mm; Connector Height 2: 646 mm; Connector Height 3: 745 mm; Connector Height 4: 765 mm; Domestic Cold Water Height: 230 mm; Drain Height: 1004 mm; Family Name: HC_Boiler_MEPcontent_BAXI_BC ACS 2001E-3001E iR290_ES-ES; Service Height: 1528 mm
Pset_ManufacturerTypeInformation - Manufacturer: BAXI
Constraints - Offset: 0 mm
Dimensions - Area: 6.66788 m2; Volume: 0.501842 m3
Identity Data - Mark: 4
Mechanical - System Classification: Domestic Cold Water,Hydronic Supply,Supply Air,Exhaust Air,Sanitary,Power,Hydronic Supply,Hydronic Return,Domestic Hot Water
Mechanical - Flow - Central Heating Flow: 0 m3/s; Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Drain Fixture Units: 0; Exhaust Air Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Back Clearance Safe: 150 mm; Family: HC_Boiler_MEPcontent_BAXI_BC ACS 2001E-3001E iR290_ES-ES: BC ACS 2001E iR290; Family and Type: HC_Boiler_MEPcontent_BAXI_BC ACS 2001E-3001E iR290_ES-ES: BC ACS 2001E iR290; Front Clearance Safe: 150 mm; Left Clearance Safe: 10 mm; Legs Height Safe: 4 mm; Right Clearance Safe: 15 mm; Top Clearance Offset: 0 mm; Top Clearance Safe: 400 mm; Type: HC_Boiler_MEPcontent_BAXI_BC ACS 2001E-3001E iR290_ES-ES: BC ACS 2001E iR290; Type Id: HC_Boiler_MEPcontent_BAXI_BC ACS 2001E-3001E iR290_ES-ES: BC ACS 2001E iR290
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Back Clearance: 150 mm; Front Clearance: 150 mm; Left Clearance: 10 mm; Legs Height: 4 mm; Right Clearance: 15 mm; Show Service Area: no; Top Clearance: 400 mm
